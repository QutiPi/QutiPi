

# Disable cursor blink
CMDLINE_append = "vt.global_cursor_default=0"

